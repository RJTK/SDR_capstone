# Repository RJTK/SDR_capstone

File README:

Ryan J. Kinnear (C) 2014

Fourth year project.

The goal is to build a simple software defined radio peripheral.

## KiCad design schem/fourth_year/fourth_year.kicad_pcb

Parts:
C1, C2, C4, C7, C11, C12, C14, C15, C17, C20, C22: 1nF; 2.00mm x 1.25mm
C3: OPEN; 2.00mm x 1.25mm
C5, C39: 3pF; 2.00mm x 1.25mm
C6: 10uF
C8: .1uF
C9: 0.47uF; 3.20mm x 1.60mm
C10, C52, C53: 3uF
C13: 1.5nF; 2.00mm x 1.25mm
C16: 33nF; 1.25mm x 2.00mm WIDE
C18, C19: 26pF; 2.00mm x 1.25mm
C21: 18pF; 1.00mm x 0.55mm
C23: 1uF; 2.30mm x 1.60mm
C24, C25: 10nF; 2.00mm x 1.25mm
C26, C29: 150uF
C27, C28: 3uF; 3.20mm x 2.50mm
C30: 10uF, 1ohm ESR; 3.20mm x 1.60mm
C31, C36, C45: 10uF; 2.00mm x 1.25mm
C32, C33, C34, C35, C37, C38, C47, C48: .1uF; 3.20mm x 1.60mm
C40, C41: 1uF; 3.20mmX1.60mm
C42: 22uF
C43, C44: 45pF; 1.60mm x 0.80mm
C46: 82pF; 3.20mm x 1.60mm
C49, C57, C58, C59, C60, C61: 47uF
C50: 1uF; 3.20mm x 1.60mm
C51: 100uF
C54, C55, C56: 1uF
D1: 1N5817; THROUGH HOLE
L1, L7: OPEN
L2: 47nH; 1.60mm x 0.80mm
L3: 270nH; 1.60mm x 0.80mm
L4: 68nH; 1.60mm x 0.80mm
L5: 15nH; 1.60mm x 0.80mm
L6: 19nH; 1.19mm x 0.64mm
L9: 150nH; 1.60mm x 0.80mm
L10, L12: FERRITE BEAD; 1.00mm x 0.50mm
L18, L19: 112nH; 1.60mm x 0.80mm
L20: OPEN; 3.20mm x 1.60mm
L21: 10uH; 3.20mm x 1.60mm
L22: 22uH; 3.20mm x 1.60mm
P1: F Type; F TYPE CONN
P2: SAW
P3, P5, P11, P12: CONNECTOR; FEMALE CONN THROUGH HOLE
P4: DC JACK; JACK
P6, P9: CONN_6; THROUGH HOLE CONN
P7, P8: BNC
P10: BNC
Q1: LT1086
Q2: UA78L05
R2: 560; 3.20mm x 1.60mm
R3: OPEN / 360; 2.00mm x 1.25mm
R4: 100/OPEN; 3.20mm x 1.60mm
R5, R6, R9, R10, R13: 10K; 3.20mm x 1.60mm
R7, R8, R11, R12: 500; 3.20mm x 1.60mm
R14: 20K; 3.20mm x 1.60mm
R16, R17: 120/SHORT; 3.20mm x 1.60mm
T1: TRANSFO4
U1: MAX3543
U2: AD8138
U3: TPS7330QP
U4: AD9235; THROUGH HOLE CONN
U5: FMC_LPC
U6, U7: 74VHC541FT
U8: TPS6735
X1: CRYSTAL

Connections:
3V: C30.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, R9.1, R13.1, U3.5 (Vout), U3.6 (Vout), U3.7 (SENSE), U4.7 (AVDD), U4.12 (AVDD), U4.24 (DRVDD)
3V3: C1.1, C2.1, C6.1, C7.2, C8.1, C11.1, C12.1, C22.1, C23.1, C29.1, C48.1, C52.1, L3.1, L10.2, L12.1, Q1.2 (OUT), R5.1, R6.1, U1.13 (VCC), U1.27 (VCC), U1.29 (VCC), U1.39 (VCC), U3.3 (Vin), U3.4 (Vin)
5V: C28.1, C37.1, C49.1, C50.1, Q2.1, U2.3 (V+), U8.1 (EN), U8.8 (Vcc)
-5V: C38.1, C42.2, L22.2, U2.6 (V-)
/RF_IN: C3.1, L2.1, P1.1 (In)
GND: C1.2, C2.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, C16.1, C19.2, C22.2, C23.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.1, C45.2, C46.2, C47.1, C48.2, C49.2, C50.2, C51.1, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, L1.1, L7.2, L20.1, L21.2, P1.2 (Ext), P2.3, P4.2 (Ext), P7.2 (Ext), P8.2 (Ext), P10.2 (Ext), Q1.1 (ADJ), Q2.2, R10.2, R14.2, T1.2 (PM), T1.4 (S1), U1.1 (RFINH), U1.9 (ADDR), U1.12 (GND), U1.17 (GND), U1.23 (REFDIV), U1.26 (GND), U3.1 (GND), U3.2 (EN), U4.3 (SENSE), U4.8 (AGND), U4.11 (AGND), U4.14 (PDWN), U4.23 (DGND), U5.C1 (GND), U5.C4 (GND)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
unnamed: U5.H16 (LA11_P), U6.12 (Y7)
unnamed: U5.H13 (LA07_P), U6.13 (Y6)
unnamed: L12.2, U1.19 (VCCDIG)
unnamed: U5.H25 (LA21_P), U7.18 (Y1)
unnamed: U4.28 (D11), U6.5 (A4)
unnamed: U4.18 (D3), U7.5 (A4)
unnamed: U4.19 (D4), U7.4 (A3)
unnamed: U4.20 (D5), U7.3 (A2)
unnamed: U4.21 (D6), U7.2 (A1)
unnamed: U4.22 (D7), U6.9 (A8)
unnamed: U4.25 (D8), U6.8 (A7)
unnamed: U4.26 (D9), U6.7 (A6)
unnamed: U4.27 (D10), U6.6 (A5)
unnamed: U4.1 (OTR), U6.4 (A3)
unnamed: U5.H34 (LA30_P), U7.14 (Y5)
unnamed: U5.H32 (LA28_N), U7.15 (Y4)
unnamed: U5.H31 (LA28_P), U7.16 (Y3)
unnamed: U5.H28 (LA24_P), U7.17 (Y2)
unnamed: U5.H22 (LA19_P), U6.11 (Y8)
unnamed: U4.13 (CLK), U5.H37 (LA32_P)
unnamed: P6.2, U4.9 (VIN+)
unnamed: P9.3, T1.3 (PR2)
unnamed: L20.2, P10.1 (In), T1.5 (S2)
unnamed: U5.H8 (LA02_N), U6.15 (Y4)
unnamed: U5.H7 (LA02_P), U6.16 (Y3)
unnamed: C51.2, D1.1 (A), L22.1, U8.5 (FB)
unnamed: D1.2 (K), L21.1, U8.7 (OUT)
unnamed: C46.1, U8.4 (COMP)
unnamed: C45.1, U8.2 (REF)
unnamed: U5.H35 (LA30_N), U7.13 (Y6)
unnamed: U4.15 (D0), U7.8 (A7)
unnamed: U4.16 (D1), U7.7 (A6)
unnamed: U4.17 (D2), U7.6 (A5)
unnamed: P6.3, P9.4
unnamed: P6.6, P9.1
unnamed: L9.1, U1.31 (TFVL2)
unnamed: L4.1, U1.33 (TFVH2)
unnamed: L5.1, U1.35 (TFU2A)
unnamed: L3.2, U1.38 (LEXT)
unnamed: L6.1, U1.37 (TFU3)
unnamed: C4.1, U1.40 (RFINL)
unnamed: C18.2, C21.2, U1.21 (XTALB)
unnamed: C18.1, C19.1, U1.22 (XTALE)
unnamed: C13.2, R2.2, U1.25 (TUNE)
unnamed: C16.2, R2.1
unnamed: C9.1, U1.28 (LDOBYP)
unnamed: C21.1, X1.1
unnamed: C14.1, U1.2 (RFGND1)
unnamed: L6.2, U1.36 (TFU2B)
unnamed: L5.2, U1.34 (TFU1)
unnamed: L4.2, U1.32 (TFVH1)
unnamed: L9.2, U1.30 (TFVL1)
unnamed: C15.1, U1.5 (RFGND2)
unnamed: L10.1, U1.4 (VCCIF)
unnamed: P2.2, R3.1, U1.10 (IFIN-)
unnamed: P2.1, R3.2, U1.11 (IFIN+)
unnamed: C20.1, P2.4
unnamed: C20.2, U1.7 (IFOUT1B)
unnamed: C17.2, U1.6 (IFOUT1A)
unnamed: C25.1, U1.15 (DTVOUT-)
unnamed: R13.2, R14.1, U4.2 (MODE)
unnamed: R4.2, R12.2, R17.1, U2.5 (-)
unnamed: R7.2, R11.1, U2.8 (+)
unnamed: C24.2, L1.2, R7.1
unnamed: P9.6, T1.1 (PR1)
unnamed: P6.5, U4.10 (VIN-)
unnamed: P6.1, P7.1 (In)
unnamed: P6.4, P8.1 (In)
unnamed: C3.2, C4.2, C5.1, C39.1, L2.2
unnamed: C53.1, P12.1, U1.8 (IFVGC)
unnamed: C17.1, P2.5
unnamed: C10.1, P11.1, U1.3 (RFVGC)
unnamed: U5.H10 (LA04_P), U6.14 (Y5)
unnamed: P5.1, R6.2, U1.20 (SCL)
unnamed: C24.1, U1.16 (DTVOUT+)
unnamed: C25.2, L7.1, R8.1
unnamed: R4.1, R11.2, R16.1, U2.4 (+)
unnamed: C26.1, C27.1, C47.2, P4.1 (In), Q1.3 (IN), Q2.3
unnamed: R9.2, R10.1, U2.2 (OCM)
unnamed: P3.1, R5.2, U1.24 (SDA)
unnamed: C31.1, C32.1, U4.4 (Vref)
unnamed: C34.1, C35.1, C36.1, U4.5 (REFB)
unnamed: C33.1, C35.2, C36.2, U4.6 (REFT)
unnamed: R8.2, R12.1, U2.1 (-)
unnamed: C40.1, C41.1, C60.1, C61.1, U5.H40 (VADJ_(2v5)), U6.20 (VCC), U7.20 (VCC)
unnamed: C44.2, L19.1, P9.5
unnamed: C44.1, L18.2, P9.2
unnamed: C43.2, L19.2, R17.2
unnamed: C43.1, L18.1, R16.2

Notes on the sheet:
Female Conn. To BBB.
For DC blocking
PLL Charge Pump
Clapp Oscillator
Diplex Filter
No idea what this is for
RF TAP?
Function Generator Inputs
Matching Inductor
2v5
LINE DRIVERS
CLK
50 OHM LINES
75 OHM LINES
SEE SPICE MODEL & GENESYS
AA and Noise Supression Filter
120 ohm
100 ohm
The high frequency side has been eliminated
POWER STAR ROOT FOR MAX3543
I've put the + signal into the - input for board routing convenience.
ADD SCHMITT TRIGGER

Board: 2 copper layers, 217.9 x 75.9 mm, 116 parts (1 on the bottom side), 95 nets.

## Commit log

2014-09-23 Started model for FM radio mod/demod
2014-09-23 I think the FM modulation works
2014-09-25 Added ability to read and modulate .wav files
2014-09-28 Working on fm demod...
2014-10-15 Radio demodulation works! Now to inject noise...
2014-10-15 AWGN channel works
2014-10-16 Limiter_Discriminator works
2014-10-16 Fixed some bugs, works well. Still no BB demodulation working
2014-10-16 Bandpass limiter switch
2014-10-31 Added heavy distortion channel
2014-11-24 filter test PCB mostly completed
2014-12-07 Added ADC to model, updated schematic, created test data generator
2014-12-22 Minor schem modifications, started final report
2014-12-24 Substantial progress on final report
2014-12-24 More work on final report
2014-12-25 Final report additions
2014-12-27 Created fmc_lpc pad (see make_fmc_pads.py). Broke up model src files.
2014-12-29 Some minor schematic work
2015-01-01 Minor schematic updates
2015-01-03 Some SPICE modeling
2015-01-05 Schematic complete. Started work on pcb layout
2015-01-05 Removed a few dead files
2015-01-05 minor file updates
2015-01-05 Eliminated UHF input
2015-01-06 Progress on main PCB
2015-01-06 More work on PCB
2015-01-07 Router power
2015-01-07 Minor changes
2015-01-08 More PCB work
2015-01-10 Started routing ADC
2015-01-10 Routed line drivers
2015-01-10 Minor update
2015-01-14 Completed ENEL417 prelim document, also minor PCB updates
2015-01-14 Minor checkout plan update
2015-01-14 Another minor checkout plan update
2015-01-17 PCB routing done. Doing some optimization and copper fills
2015-01-17 Polishing PCB layout. Ground planes, copper pours, vias etc... Checking correctness
2015-01-19 Some polish on PCB, from yesterday...
2015-01-22 PCB finalized, order has been placed
2015-01-25 Some work on final report
2015-02-06 Working on multipath channel
2015-02-06 PCB corrections, changed to REV2
2015-02-08 Added to system design and project scope of final report.
2015-02-16 Additions to final report
2015-02-19 Work on report, added zero crossing demodulator to models
2015-02-19 Branches would probably have been wise.
2015-02-19 Branch?
2015-02-19 Report_Dev branch
2015-02-19 Control code for MAX3543
2015-02-19 Work on AD8138 section
2015-02-19 Added section on DSP vs FPGA
2015-02-21 Developed and tested FPGA PWM audio module
2015-03-15 Updates to report
